# Keil uVision project super_cap_buck_v3.uvprojx, settings and files
target super_cap_buck_v3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: super_cap_buck_v3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;                             ../Drivers/STM32G4xx_HAL_Driver/Inc;                             ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                             ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                             ../Drivers/CMSIS/Include;                             .\USER\Alg;                             .\USER\All_Init;                             .\USER\Cap_Control;                             .\USER\Chassis_Ctr;                             .\USER\Peripheral;                             .\USER\Power_Control;                             .\USER\Str;                             .\USER\Utility;                             .\USER;                             .\USER\Lib
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
    ./USER/: configue.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dac.c dma.c fdcan.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Alg
    ./USER/Alg/: filter_alg.c mppt_alg.c pid_alg.c
  group Power_Control
    ./USER/Power_Control/: Power_Control.c
  group Cap_Control
    ./USER/Cap_Control/: Cap_Control.c Decoder.c Error_Handle.c Power_Path_Control.c
  group Peripher
    ./USER/Peripheral/: AD8402_Periph.c boost_Periph.c debug_BTlog.c oled_periph.c
  group Utility
    ./USER/Utility/: adc_util.c dac_util.c uart_util.c fdcan_util.c i2c_util.c
  group Str
    ./USER/Str/: Queue_Str.c
  group Lib
    ./USER/Lib/: font_lib.c
software components: CMSIS:CORE 5.5.0
